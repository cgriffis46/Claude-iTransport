#pragma once
// AES-128 (FIPS-197). LoRaWAN only ever runs the cipher forwards: frame
// payloads are XORed with AES(key, A_i) blocks, the MIC is AES-CMAC, and
// even the Join-Accept is "decrypted" on the device with AES encrypt (the
// network server encrypts it with AES decrypt). MeshCore uses AES-128 in
// ECB mode both ways, so decrypt() is here too (the inverse cipher,
// FIPS-197 section 5.3).
//
// Byte-oriented and table-light (the S-box and its inverse), header-only, no heap.
// Not hardened against timing or power analysis: the S-box lookups depend
// on the key and data. Checked against FIPS-197 Appendix C.1 (both
// ways) and the RFC 4493 vectors (iRadio/test/aes_cmac_test.cpp).

#include <stdint.h>
#include <string.h>

class Aes128 {
public:
	static const uint8_t kBlock = 16;

	Aes128() { memset(_rk, 0, sizeof _rk); }
	explicit Aes128(const uint8_t key[16]) { setKey(key); }
	~Aes128() { wipe(); }

	void setKey(const uint8_t key[16]) {
		memcpy(_rk, key, 16);
		uint8_t rcon = 0x01;
		for (int i = 16; i < 176; i += 4) {
			uint8_t t[4] = {_rk[i - 4], _rk[i - 3], _rk[i - 2], _rk[i - 1]};
			if (i % 16 == 0) {
				const uint8_t first = t[0];   // RotWord, SubWord, Rcon
				t[0] = (uint8_t)(sbox(t[1]) ^ rcon);
				t[1] = sbox(t[2]);
				t[2] = sbox(t[3]);
				t[3] = sbox(first);
				rcon = xtime(rcon);
			}
			for (int k = 0; k < 4; ++k) _rk[i + k] = (uint8_t)(_rk[i - 16 + k] ^ t[k]);
		}
	}

	// out may be the same as in.
	void encrypt(const uint8_t in[16], uint8_t out[16]) const {
		uint8_t s[16];
		for (int i = 0; i < 16; ++i) s[i] = (uint8_t)(in[i] ^ _rk[i]);
		for (int round = 1; round <= 10; ++round) {
			// SubBytes and ShiftRows together (state is column-major).
			uint8_t t[16];
			for (int c = 0; c < 4; ++c)
				for (int r = 0; r < 4; ++r) t[4 * c + r] = sbox(s[4 * ((c + r) & 3) + r]);
			if (round < 10) {   // MixColumns
				for (int c = 0; c < 4; ++c) {
					const uint8_t a0 = t[4 * c], a1 = t[4 * c + 1], a2 = t[4 * c + 2], a3 = t[4 * c + 3];
					const uint8_t all = (uint8_t)(a0 ^ a1 ^ a2 ^ a3);
					t[4 * c]     = (uint8_t)(a0 ^ all ^ xtime((uint8_t)(a0 ^ a1)));
					t[4 * c + 1] = (uint8_t)(a1 ^ all ^ xtime((uint8_t)(a1 ^ a2)));
					t[4 * c + 2] = (uint8_t)(a2 ^ all ^ xtime((uint8_t)(a2 ^ a3)));
					t[4 * c + 3] = (uint8_t)(a3 ^ all ^ xtime((uint8_t)(a3 ^ a0)));
				}
			}
			for (int i = 0; i < 16; ++i) s[i] = (uint8_t)(t[i] ^ _rk[16 * round + i]);
		}
		memcpy(out, s, 16);
	}

	// The inverse cipher. out may be the same as in.
	void decrypt(const uint8_t in[16], uint8_t out[16]) const {
		uint8_t s[16];
		for (int i = 0; i < 16; ++i) s[i] = (uint8_t)(in[i] ^ _rk[160 + i]);
		for (int round = 9; round >= 0; --round) {
			// InvShiftRows and InvSubBytes together, then AddRoundKey.
			uint8_t t[16];
			for (int c = 0; c < 4; ++c)
				for (int r = 0; r < 4; ++r) t[4 * ((c + r) & 3) + r] = invSbox(s[4 * c + r]);
			for (int i = 0; i < 16; ++i) t[i] = (uint8_t)(t[i] ^ _rk[16 * round + i]);
			if (round > 0) {   // InvMixColumns: {0e 0b 0d 09}
				for (int c = 0; c < 4; ++c) {
					const uint8_t a0 = t[4 * c], a1 = t[4 * c + 1], a2 = t[4 * c + 2], a3 = t[4 * c + 3];
					s[4 * c]     = (uint8_t)(mul(a0, 14) ^ mul(a1, 11) ^ mul(a2, 13) ^ mul(a3, 9));
					s[4 * c + 1] = (uint8_t)(mul(a0, 9) ^ mul(a1, 14) ^ mul(a2, 11) ^ mul(a3, 13));
					s[4 * c + 2] = (uint8_t)(mul(a0, 13) ^ mul(a1, 9) ^ mul(a2, 14) ^ mul(a3, 11));
					s[4 * c + 3] = (uint8_t)(mul(a0, 11) ^ mul(a1, 13) ^ mul(a2, 9) ^ mul(a3, 14));
				}
			} else {
				memcpy(s, t, 16);
			}
		}
		memcpy(out, s, 16);
	}

	// Forgets the key schedule (also done by the destructor).
	void wipe() {
		volatile uint8_t* p = _rk;
		for (size_t i = 0; i < sizeof _rk; ++i) p[i] = 0;
	}

private:
	static uint8_t xtime(uint8_t x) { return (uint8_t)((x << 1) ^ ((x & 0x80) ? 0x1B : 0x00)); }
	// Multiplication in GF(2^8), for InvMixColumns' small constants.
	static uint8_t mul(uint8_t a, uint8_t b) {
		uint8_t r = 0;
		while (b) {
			if (b & 1) r ^= a;
			a = xtime(a);
			b >>= 1;
		}
		return r;
	}
	static uint8_t invSbox(uint8_t x) {
		static const uint8_t s[256] = {
			0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
			0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb,
			0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e,
			0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25,
			0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92,
			0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84,
			0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06,
			0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b,
			0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73,
			0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e,
			0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b,
			0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4,
			0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f,
			0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef,
			0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61,
			0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x0c, 0x7d};
		return s[x];
	}
	static uint8_t sbox(uint8_t x) {
		static const uint8_t s[256] = {
			0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
			0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
			0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
			0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
			0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
			0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
			0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
			0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
			0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
			0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
			0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
			0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
			0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
			0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
			0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
			0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16};
		return s[x];
	}

	uint8_t _rk[176];   // the 11 round keys
};
