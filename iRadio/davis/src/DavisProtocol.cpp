#include "DavisProtocol.h"

namespace DAVIS {

// RegFrfMsb/Mid/Lsb for each channel, in Davis's hop order. A station
// moves to the next entry each time it sends.
static const uint8_t kFrfUs[51][3] = {
	{0xE3, 0xDA, 0x7C}, {0xE1, 0x98, 0x71}, {0xE3, 0xFA, 0x92}, {0xE6, 0xBD, 0x01},
	{0xE4, 0xBB, 0x4D}, {0xE2, 0x99, 0x56}, {0xE7, 0x7D, 0xBC}, {0xE5, 0x9C, 0x0E},
	{0xE3, 0x39, 0xE6}, {0xE6, 0x1C, 0x81}, {0xE4, 0x5A, 0xE8}, {0xE1, 0xF8, 0xD6},
	{0xE5, 0x3B, 0xBF}, {0xE7, 0x1D, 0x5F}, {0xE3, 0x9A, 0x3C}, {0xE2, 0x39, 0x00},
	{0xE4, 0xFB, 0x77}, {0xE6, 0x5C, 0xB2}, {0xE2, 0xD9, 0x90}, {0xE7, 0xBD, 0xEE},
	{0xE4, 0x3A, 0xD2}, {0xE1, 0xD8, 0xAA}, {0xE5, 0x5B, 0xCD}, {0xE6, 0xDD, 0x34},
	{0xE3, 0x5A, 0x0A}, {0xE7, 0x9D, 0xD9}, {0xE2, 0x79, 0x41}, {0xE4, 0x9B, 0x28},
	{0xE5, 0xDC, 0x40}, {0xE7, 0x3D, 0x74}, {0xE1, 0xB8, 0x9C}, {0xE3, 0xBA, 0x60},
	{0xE6, 0x7C, 0xC8}, {0xE4, 0xDB, 0x62}, {0xE2, 0xB9, 0x7A}, {0xE5, 0x7B, 0xE2},
	{0xE7, 0xDE, 0x12}, {0xE6, 0x3C, 0x9D}, {0xE3, 0x19, 0xC9}, {0xE4, 0x1A, 0xB6},
	{0xE5, 0xBC, 0x2B}, {0xE2, 0x18, 0xEB}, {0xE6, 0xFD, 0x42}, {0xE5, 0x1B, 0xA3},
	{0xE3, 0x7A, 0x2E}, {0xE5, 0xFC, 0x64}, {0xE2, 0x59, 0x16}, {0xE6, 0x9C, 0xEC},
	{0xE2, 0xF9, 0xAC}, {0xE4, 0x7B, 0x0C}, {0xE7, 0x5D, 0x98},
};

static const uint8_t kFrfAu[51][3] = {
	{0xE5, 0x84, 0xDD}, {0xE6, 0x43, 0x43}, {0xE7, 0x1F, 0xCE}, {0xE6, 0x7F, 0x7C},
	{0xE5, 0xD5, 0x0E}, {0xE7, 0x5B, 0xF7}, {0xE6, 0xC5, 0x81}, {0xE6, 0x07, 0x2B},
	{0xE6, 0xED, 0xA1}, {0xE6, 0x61, 0x58}, {0xE5, 0xA3, 0x02}, {0xE6, 0xA7, 0x8D},
	{0xE7, 0x3D, 0xB2}, {0xE6, 0x25, 0x3F}, {0xE5, 0xB7, 0x0A}, {0xE6, 0x93, 0x85},
	{0xE7, 0x01, 0xDB}, {0xE5, 0xE9, 0x26}, {0xE7, 0x70, 0x00}, {0xE6, 0x57, 0x6C},
	{0xE5, 0x98, 0xF5}, {0xE6, 0xB1, 0x99}, {0xE7, 0x29, 0xDB}, {0xE6, 0x11, 0x37},
	{0xE7, 0x65, 0xE3}, {0xE5, 0xCB, 0x33}, {0xE6, 0x75, 0x60}, {0xE6, 0xD9, 0xA9},
	{0xE7, 0x47, 0xDF}, {0xE5, 0x8E, 0xF9}, {0xE6, 0x2F, 0x4B}, {0xE7, 0x0B, 0xB6},
	{0xE6, 0x89, 0x68}, {0xE5, 0xDF, 0x2B}, {0xE6, 0xBB, 0xA5}, {0xE7, 0x79, 0xFB},
	{0xE6, 0xF7, 0xAE}, {0xE5, 0xFD, 0x2F}, {0xE6, 0x4D, 0x4F}, {0xE6, 0xCF, 0x8D},
	{0xE5, 0xAD, 0x0E}, {0xE7, 0x33, 0xD7}, {0xE6, 0x9D, 0x91}, {0xE6, 0x1B, 0x33},
	{0xE6, 0xE3, 0xA5}, {0xE5, 0xC1, 0x16}, {0xE7, 0x15, 0xC2}, {0xE5, 0xF3, 0x33},
	{0xE6, 0x6B, 0x64}, {0xE7, 0x51, 0xDB}, {0xE6, 0x39, 0x58},
};

static const uint8_t kFrfEu[5][3] = {
	{0xD9, 0x04, 0x45}, {0xD9, 0x13, 0x04}, {0xD9, 0x21, 0xC2}, {0xD9, 0x0B, 0xA4},
	{0xD9, 0x1A, 0x63},
};

static const uint8_t kFrfNz[51][3] = {
	{0xE6, 0x45, 0x0E}, {0xE7, 0x43, 0xC7}, {0xE6, 0xF4, 0xAC}, {0xE6, 0x9C, 0xEE},
	{0xE7, 0xA4, 0x7B}, {0xE6, 0xC0, 0x31}, {0xE7, 0xD0, 0x52}, {0xE7, 0x20, 0x93},
	{0xE6, 0x68, 0x31}, {0xE7, 0x67, 0x0A}, {0xE6, 0xDA, 0x5E}, {0xE7, 0xE1, 0xEC},
	{0xE7, 0x8A, 0x0C}, {0xE6, 0x82, 0xA0}, {0xE7, 0x0F, 0x1B}, {0xE7, 0xBE, 0xE9},
	{0xE6, 0xB7, 0x3B}, {0xE7, 0x4C, 0x6A}, {0xE7, 0xFC, 0x5A}, {0xE6, 0x4D, 0xF4},
	{0xE7, 0x92, 0xD1}, {0xE6, 0xEB, 0xF8}, {0xE6, 0x94, 0x39}, {0xE7, 0xEA, 0xC1},
	{0xE7, 0x29, 0x79}, {0xE6, 0x5F, 0x7D}, {0xE7, 0x5E, 0x35}, {0xE6, 0xC8, 0xC5},
	{0xE7, 0xB6, 0x25}, {0xE6, 0xA5, 0xB2}, {0xE6, 0xFD, 0x81}, {0xE7, 0x6F, 0xCF},
	{0xE6, 0x79, 0xCB}, {0xE7, 0x9B, 0xB6}, {0xE7, 0x32, 0x2D}, {0xE7, 0xC7, 0x7D},
	{0xE6, 0x8B, 0x54}, {0xE7, 0x81, 0x37}, {0xE6, 0xD1, 0x89}, {0xE7, 0x55, 0x60},
	{0xE7, 0xD9, 0x17}, {0xE6, 0x56, 0xA8}, {0xE7, 0x06, 0x35}, {0xE7, 0xAD, 0x2F},
	{0xE6, 0xAE, 0x77}, {0xE7, 0x3B, 0x12}, {0xE7, 0xF3, 0x85}, {0xE6, 0x71, 0x06},
	{0xE7, 0x17, 0xCF}, {0xE6, 0xE3, 0x12}, {0xE7, 0x78, 0xA4},
};

static const uint8_t (*const kBandFrf[4])[3] = { kFrfUs, kFrfAu, kFrfEu, kFrfNz };
static const uint8_t kBandLen[4] = { 51, 51, 5, 51 };

uint8_t bandChannels(davis_band_t band) {
	return (unsigned)band < 4 ? kBandLen[band] : kBandLen[0];
}

const uint8_t* bandFrf(davis_band_t band, uint8_t channel) {
	const unsigned b = (unsigned)band < 4 ? (unsigned)band : 0;
	if (channel >= kBandLen[b]) channel = 0;
	return kBandFrf[b][channel];
}

uint32_t channelHz(davis_band_t band, uint8_t channel) {
	const uint8_t* f = bandFrf(band, channel);
	const uint32_t frf = ((uint32_t)f[0] << 16) | ((uint32_t)f[1] << 8) | f[2];
	// FXOSC / 2^19 = 32 MHz / 524288 = 61.03515625 Hz = 15625 / 256
	return (uint32_t)(((uint64_t)frf * 15625u) >> 8);
}

uint8_t reverseBits(uint8_t b) {
	b = (uint8_t)(((b & 0xF0) >> 4) | ((b & 0x0F) << 4));
	b = (uint8_t)(((b & 0xCC) >> 2) | ((b & 0x33) << 2));
	b = (uint8_t)(((b & 0xAA) >> 1) | ((b & 0x55) << 1));
	return b;
}

uint16_t crc16(const uint8_t* buf, uint8_t len, uint16_t init) {
	uint16_t crc = init;
	while (len--) {
		crc ^= (uint16_t)(*buf++) << 8;
		for (uint8_t i = 0; i < 8; ++i)
			crc = (crc & 0x8000) ? (uint16_t)((crc << 1) ^ 0x1021) : (uint16_t)(crc << 1);
	}
	return crc;
}

davis_crc_t checkCrc(const uint8_t raw[kPacketLen]) {
	const uint16_t got = (uint16_t)((raw[6] << 8) | raw[7]);
	if (got == 0) return davis_crc_bad;
	const uint16_t direct = crc16(raw, 6);
	if (direct == got) return davis_crc_direct;
	if (crc16(raw + 8, 2, direct) == got) return davis_crc_repeater;
	return davis_crc_bad;
}

void buildPacket(const uint8_t data[6], uint8_t out[kPacketLen]) {
	for (uint8_t i = 0; i < 6; ++i) out[i] = data[i];
	const uint16_t crc = crc16(data, 6);
	out[6] = (uint8_t)(crc >> 8);
	out[7] = (uint8_t)(crc & 0xFF);
	out[8] = 0xFF;
	out[9] = 0xFF;
}

static float nanf_() { return __builtin_nanf(""); }

void decode(const uint8_t raw[kPacketLen], bool vue, DavisReading& r) {
	r.station = raw[0] & 0x07;
	r.type = (uint8_t)(raw[0] >> 4);
	r.batteryLow = (raw[0] & 0x08) != 0;
	r.windSpeedMph = raw[1];
	r.gustIndex = 0;
	r.value = nanf_();

	if (raw[2] == 0) {
		r.windDirDeg = nanf_();				// no anemometer
	} else if (vue) {
		const uint16_t d = (uint16_t)((raw[2] << 1) | ((raw[4] & 0x02) >> 1));	// 9 bits
		r.windDirDeg = (float)d * 360.0f / 512.0f;
	} else {
		r.windDirDeg = 9.0f + (float)(raw[2] - 1) * 342.0f / 255.0f;
	}

	const uint16_t hi10 = (uint16_t)(((raw[3] << 8) | raw[4]) >> 6);	// a 10 bit value in bytes 3-4
	switch (r.type) {
	case DAVIS_MSG_TEMP:
		if (raw[3] != 0xFF) r.value = (float)(int16_t)((raw[3] << 8) | raw[4]) / 160.0f;
		break;
	case DAVIS_MSG_HUMIDITY: {
		const uint16_t h = (uint16_t)(((raw[4] >> 4) << 8) | raw[3]);
		if (h != 0) r.value = (float)h / 10.0f;
		break;
	}
	case DAVIS_MSG_UV:
		if (hi10 < 0x3FF) r.value = (float)hi10 / 50.0f;
		break;
	case DAVIS_MSG_SOLAR:
		if (hi10 < 0x3FE) r.value = (float)hi10 * 1.757936f;
		break;
	case DAVIS_MSG_VCAP:
	case DAVIS_MSG_VSOLAR:
		r.value = (float)((raw[3] << 2) | ((raw[4] & 0xC0) >> 6)) / 100.0f;
		break;
	case DAVIS_MSG_GUST:
		r.value = raw[3];
		r.gustIndex = (uint8_t)((raw[5] & 0xF0) >> 4);
		break;
	case DAVIS_MSG_RAIN:
		if (raw[3] != 0x80) r.value = (float)(raw[3] & 0x7F);
		break;
	case DAVIS_MSG_RAINSECS: {
		// Light rain: byte 4 bits 5-4 and byte 3, 10 bits of seconds.
		// Heavy rain (byte 4 bit 6 clear): the same 10 bits hold the
		// seconds times 16.
		uint16_t s = (uint16_t)(((raw[4] & 0x30) << 4) | raw[3]);
		if (s != 0x3FF) {
			if ((raw[4] & 0x40) == 0) s >>= 4;
			r.value = (float)s;
		}
		break;
	}
	default:
		break;
	}
}

} /* namespace DAVIS */
